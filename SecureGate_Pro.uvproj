# Keil uVision project SecureGate_Pro.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SecureGate_Pro +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Application
    ./: Startup.s
    ./src/: main.c admin.c delay.c eeprom.c i2c.c interrupt.c keypad.c lcd.c motor.c r305.c rtc.c uart0.c uart1.c
